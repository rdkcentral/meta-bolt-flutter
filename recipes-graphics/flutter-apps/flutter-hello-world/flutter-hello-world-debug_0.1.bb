require flutter-hello-world_0.1.inc
inherit flutter-mode-debug