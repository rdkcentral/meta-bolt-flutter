SUMMARY = "Flutter hello world app in bolt image"

inherit base-bolt-image
IMAGE_INSTALL += "flutter-hello-world-debug"