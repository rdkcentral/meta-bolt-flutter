SUMMARY = "Flutter key mapping validator app in bolt image"

inherit base-bolt-image
IMAGE_INSTALL += "flutter-key-mapping-validator-debug"
