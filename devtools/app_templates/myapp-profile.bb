include myapp.inc
inherit flutter-mode-profile