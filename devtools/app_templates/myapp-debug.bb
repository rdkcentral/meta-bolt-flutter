include myapp.inc
inherit flutter-mode-debug