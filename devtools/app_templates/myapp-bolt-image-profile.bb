SUMMARY = "My magnificent app"

inherit base-bolt-image
IMAGE_INSTALL += "myapp-profile"
