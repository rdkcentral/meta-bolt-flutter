SUMMARY = "My magnificient app"

inherit base-bolt-image
IMAGE_INSTALL += "myapp-debug"
