include myapp.inc
inherit flutter-mode-release